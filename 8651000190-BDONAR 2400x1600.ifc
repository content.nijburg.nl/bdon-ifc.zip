Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Project Number
Time: 2022-06-01T09:28:48+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.10.18 - Exporter 23.0.10.18 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingElementProxy: NLRS_57_DUA_UN_roof kerb for penthouse louvre LT_sacs:BDONAR, NLRS_57_DUA_UN_roof kerb for penthouse louvre LT_sacs:BDONAR:1632728
In: Default
Type - Classification: 57.0 (Uniformat); Material: NLRS_57_aluminium_gen_sacs
Type - Constraints - Default Elevation: 0 mm
Type - General - LookupTable: BDON
Type - Identity Data - Assembly Code: 57.0; Description: Aluminum roof curb, insulated; Manufacturer: Solid Air Climate Solutions; Model: Solid Air roof curb, BDON; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 22-04-2021; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.18.01; NLRS_C_description: Aluminum roof curb, insulated; NLRS_C_niveau ontwikkeling: LOD 400; Type Name: BDONAR
Type - Materials and Finishes - SACS_Face_Color: NLRS_57_aluminium_gen_sacs; SACS_Material: seawater proof aluminium
Type - Other - Category: Duct Accessories; Family Name: NLRS_57_DUA_UN_roof kerb for penthouse louvre LT_sacs; SACS_Base_Index: 4
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_BuildingElementProxyCommon - Reference: BDONAR; sets with these values: 2
Pset_ProvisionForVoid - Depth: 2 mm
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no
Dimensions - Area: 8.30085 m2; NLRS_M_c01_breedte: 2400 mm; NLRS_M_c01_hoogte: 1600 mm; SACS_Height: 1600 mm; SACS_Width: 2400 mm; Volume: 0.13862 m3
Identity Data - Mark: 458; NLRS_C_model: BDONAR 2400x1600; SACS_Article_Code: 8651000190; SACS_Gross_Cost: 1253; SACS_Price_Date: 01-04-2021
Insulation - Insulation Thickness: 0 mm
Lining - Lining Thickness: 0 mm
Other - Family: NLRS_57_DUA_UN_roof kerb for penthouse louvre LT_sacs; Family and Type: NLRS_57_DUA_UN_roof kerb for penthouse louvre LT_sacs: BDONAR; Type: BDONAR; Type Id: 1631901
Phasing - Phase Created: New Construction
